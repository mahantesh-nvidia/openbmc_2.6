FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://ipmitool_smbus.patch"

