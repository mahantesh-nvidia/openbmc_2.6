FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://add_emc1424.patch \
	file://add_tps53679.patch \
"
