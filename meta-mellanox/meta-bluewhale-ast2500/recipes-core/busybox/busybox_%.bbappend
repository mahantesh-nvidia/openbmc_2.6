FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://bluewhale-ast2500.cfg"

