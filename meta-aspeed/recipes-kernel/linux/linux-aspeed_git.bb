KBRANCH ?= "dev-4.17"
LINUX_VERSION ?= "4.17.11"

SRCREV = "${AUTOREV}"

require linux-aspeed.inc
